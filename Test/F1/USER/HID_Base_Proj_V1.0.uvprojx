# Keil uVision project HID_Base_Proj_V1.0.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HID_Base_Proj_V1.0
  AfterMake: fromelf.exe --bin -o ".\Output\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,DFU_DONWLOAD0,HID_EN0
  c include: ..\USER;..\FWlib\inc;..\CMSIS;..\USB_Library\inc;..\USB_HID\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c my_sys.c stm32f10x_it.c Debug_HW.c Debug_User.c USB_HW.c USB_User.c Cycle_User.c DFU_HW.c Flash_HW.c Version_User.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_adc.c
  group Core
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
