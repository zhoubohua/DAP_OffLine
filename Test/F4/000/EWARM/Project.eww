<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\000.ewp</path>
  </project>
  <batchBuild />
</workspace>
