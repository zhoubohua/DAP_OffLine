# Keil uVision project Cube_Demo.uvprojx, settings and files
target Cube_Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cube_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;..\Cube_Creat;..\User_Sys;..\USB_Lib\Core;..\USB_Lib\MSC;..\USB_User;..\FAT\option;..\FAT;..\DAP\Config;..\DAP\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\DAP_SWD;..\Drivers\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_i2c.c stm32f1xx_hal_sd.c stm32f1xx_ll_sdmmc.c
  group Cube_Creat
    ../Cube_Creat/: gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c dma.c usart.c spi.c sdio.c i2c.c tim.c
  group User_Sys
    ../User_Sys/: USART1_HW.c Internal_Flash.c SPI_Flash.c Cycle_User.c my_sys.c OLED_User.c Font_User.c File_User.c Logic_Control.c Key_Scan.c Choose_Serve.c Burn_Serve.c
  group USB_User
    ../USB_User/: usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c
  group USB_Core
    ../USB_Lib/Core/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_MSC
    ../USB_Lib/MSC/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c usbd_msc_storage_template.c
  group FAT
    ../FAT/: diskio.c ff.c
    ../FAT/option/: cc936.c
  group DAP
    ../DAP/Source/: DAP.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c UART.c
  group DAP_SWD
    ../DAP_SWD/: SWD_host.c SWD_flash.c STM32F10x_128.c STM32F4xx_1024.c SWD_opt.c STM32F4xx_OTP.c STM32F0xx_16.c
software components: CMSIS:CORE 5.5.0
